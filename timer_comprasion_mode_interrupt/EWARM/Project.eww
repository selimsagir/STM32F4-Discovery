<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\timer_comprasion_mode_interrupt.ewp</path>
  </project>
  <batchBuild />
</workspace>
