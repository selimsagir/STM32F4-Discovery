<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\use_adc_for_timer.ewp</path>
  </project>
  <batchBuild />
</workspace>
