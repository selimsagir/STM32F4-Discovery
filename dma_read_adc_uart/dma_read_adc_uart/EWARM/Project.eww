<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\dma_read_adc_uart.ewp</path>
  </project>
  <batchBuild />
</workspace>
