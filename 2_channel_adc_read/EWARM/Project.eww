<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\2_channel_adc_read.ewp</path>
  </project>
  <batchBuild />
</workspace>
